RDEPENDS:packagegroup-mchp-apps:pic64gx-curiosity-kit += "\
    pic64gx-linux-examples-multimedia \
"


