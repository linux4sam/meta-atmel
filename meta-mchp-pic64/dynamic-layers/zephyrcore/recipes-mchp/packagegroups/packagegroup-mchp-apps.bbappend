RDEPENDS:packagegroup-mchp-apps-amp:pic64gx-curiosity-kit-amp += " pic64gx-zephyr-amp-demo pic64gx-zephyr-amp-demo-hss"
