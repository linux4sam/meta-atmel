FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_REV = "acb0885c117e73cb6c5c9b1dd9054cb3f93507ee"

PV = "4.0.0+git${SRCPV}"

COMPATIBLE_MACHINE = "(sama5d27-som1-ek-optee-sd)"
