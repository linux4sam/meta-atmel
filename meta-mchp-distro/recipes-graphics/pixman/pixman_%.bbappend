require ${@bb.utils.contains('MCHP_FEATURES', 'mchp-pixman', '${BPN}-mchp.inc', '', d)}
