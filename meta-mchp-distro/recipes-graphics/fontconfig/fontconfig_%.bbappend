require ${@bb.utils.contains('MCHP_FEATURES', 'mchpfont', '${BPN}-mchp.inc', '', d)}
