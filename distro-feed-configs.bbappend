DISTRO_FEED_URI = "http://update.seluxit.com/stable"
SUPPORTED_EXTRA_ARCHS += "at91ariag25"
