require videoplayer.inc

SRC_URI[md5sum] = "f0afc534cd167dc61d3dda42773e41e3"
SRC_URI[sha256sum] = "56fdc194c432f32302a84710e41a6e665fb332baeddb8d359d60b731cf8dc6c7"

