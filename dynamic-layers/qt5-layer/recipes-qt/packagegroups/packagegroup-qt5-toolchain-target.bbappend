RDEPENDS_${PN} += " \
    libv4l \
    libv4l-dev \
"
