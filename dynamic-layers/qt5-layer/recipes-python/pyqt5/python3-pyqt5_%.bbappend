
REQUIRED_DISTRO_FEATURES_remove = "x11"

DISABLED_FEATURES_append += "PyQt_OpenGL"
PYQT_MODULES_remove += "QtQuick QtQuickWidgets"
