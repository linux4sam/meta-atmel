FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append_sama5d2 = "\
    file://gg.cfg \
"
