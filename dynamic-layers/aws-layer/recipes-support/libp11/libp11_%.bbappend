EXTRA_OECONF_append += "--with-pkcs11-module=/usr/lib/p11-kit-proxy.so"
