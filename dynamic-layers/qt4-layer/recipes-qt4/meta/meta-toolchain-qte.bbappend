TOOLCHAIN_TARGET_TASK += "\
			libv4l libv4l-dev \
			qt-mobility-embedded qt-mobility-embedded-dev \
			"
