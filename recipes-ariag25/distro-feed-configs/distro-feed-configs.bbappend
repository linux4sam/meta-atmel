DISTRO_FEED_URI = "http://opkg.blazingangles.com/stable"
SUPPORTED_EXTRA_ARCHS += "at91ariag25"
