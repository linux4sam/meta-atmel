EXTRA_OECONF:append:sama5d2 = " --with-pkcs11-module=/usr/lib/p11-kit-proxy.so"
EXTRA_OECONF:append:sama7 = " --with-pkcs11-module=/usr/lib/p11-kit-proxy.so"
