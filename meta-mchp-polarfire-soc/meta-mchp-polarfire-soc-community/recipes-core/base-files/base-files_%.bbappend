FILESEXTRAPATHS:prepend:beaglev-fire := "${THISDIR}/${PN}/growfs:"
