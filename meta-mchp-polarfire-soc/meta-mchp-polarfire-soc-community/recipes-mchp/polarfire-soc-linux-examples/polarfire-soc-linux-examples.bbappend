EXAMPLE_FILES:beaglev-fire = "\
    gateware"

