
RDEPENDS:packagegroup-mchp-apps:mpfs-beaglev-fire = "\
    polarfire-soc-linux-examples-gateware \
"
