IMAGE_INSTALL:append = "\
    packagegroup-mchp-apps \
    packagegroup-mchp-security \
"