FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}/motd:"

FILESEXTRAPATHS:prepend:mpfs-icicle-kit-es := "${THISDIR}/${PN}/growfs:"
FILESEXTRAPATHS:prepend:mpfs-icicle-kit-es-amp := "${THISDIR}/${PN}/growfs:"
FILESEXTRAPATHS:prepend:mpfs-disco-kit := "${THISDIR}/${PN}/growfs:"
FILESEXTRAPATHS:prepend:mpfs-video-kit := "${THISDIR}/${PN}/growfs:"
