PACKAGECONFIG:append:mpfs-video-kit = " testapp"
