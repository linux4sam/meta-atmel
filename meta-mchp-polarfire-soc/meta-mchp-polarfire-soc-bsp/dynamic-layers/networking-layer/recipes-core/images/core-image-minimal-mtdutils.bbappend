IMAGE_INSTALL += "  netcat"