RDEPENDS:packagegroup-mchp-security += "\
    libkcapi \
"
