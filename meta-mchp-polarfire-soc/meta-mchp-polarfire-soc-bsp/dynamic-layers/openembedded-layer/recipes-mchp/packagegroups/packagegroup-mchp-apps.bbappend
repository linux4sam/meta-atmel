RDEPENDS:packagegroup-mchp-apps:mpfs-icicle-kit-es += "\
    polarfire-soc-linux-examples-gpio \
"

RDEPENDS:packagegroup-mchp-apps-amp:mpfs-icicle-kit-es-amp += "\
    polarfire-soc-linux-examples-gpio \
"
