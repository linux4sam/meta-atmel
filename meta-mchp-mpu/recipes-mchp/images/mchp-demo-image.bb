DESCRIPTION = "A generic image for network and communication."
LICENSE = "MIT"
PR = "r1"

require mchp-demo-image.inc
