require u-boot-envs-mchp.inc
inherit mchp-compat-machines
