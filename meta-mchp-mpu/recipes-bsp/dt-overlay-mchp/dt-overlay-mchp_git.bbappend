inherit mchp-compat-machines
