RDEPENDS:packagegroup-mchp-multimedia-gstreamer:append:sama5d4 = "\
    g1-decoder \
    g1-binaries \
    gstreamer1.0-plugins-hantro \
"
