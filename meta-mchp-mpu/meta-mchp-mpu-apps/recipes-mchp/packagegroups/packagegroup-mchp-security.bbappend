RDEPENDS:packagegroup-mchp-security:mpuall += "\
    cryptoauthlib \
    python3-cryptoauthlib \
"

RDEPENDS:packagegroup-mchp-security:sama7g5ek-optee-sd += "\
    optee-examples \
    optee-os \
    optee-test \
"

RDEPENDS:packagegroup-mchp-security:sama5d27-som1-ek-optee-sd += "\
    optee-examples \
    optee-os \
    optee-test \
"
