IMAGE_INSTALL:append:mpuall = "\
    packagegroup-mchp-graphics \
    packagegroup-base-bluetooth \
    packagegroup-base-usbgadget \
    packagegroup-base-usbhost \
    packagegroup-base-wifi \
    packagegroup-mchp-multimedia-audio \
    "
