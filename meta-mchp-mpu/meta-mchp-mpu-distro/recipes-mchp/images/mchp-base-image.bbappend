IMAGE_INSTALL += "\
    9bit \
    alsa-utils \
    libdrm \
    libdrm-tests \
    packagegroup-base-bluetooth \
    packagegroup-base-usbgadget \
    packagegroup-base-usbhost \
    packagegroup-base-wifi \
    mchp-wireless-firmware \
    "
