PACKAGECONFIG:remove:mpuall = " directfb"
PACKAGECONFIG:remove:mpuall = " vulkan"
PACKAGECONFIG:append:mpuall = " kms"
