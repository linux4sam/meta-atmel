# The list of supported MPU machines.
# Inherit this bbclass to include the compatible machines.
COMPATIBLE_MACHINE = "(\
sama5d2-icp|\
sama5d2-ptc-ek|\
sama5d2-xplained|\
sama5d27-som1-ek|\
sama5d27-wlsom1-ek|\
sama5d29-curiosity|\
sama5d3-xplained|\
sama5d4-xplained|\
sama7d65-curiosity|\
sama7g5ek|\
sam9x60-curiosity|\
sam9x60ek|\
sam9x75-curiosity\
sam9x75eb|\
)"
