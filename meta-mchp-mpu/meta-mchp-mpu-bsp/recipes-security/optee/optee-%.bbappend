COMPATIBLE_MACHINE:append = " |sama5d27-som1-ek-optee-sd|sama7g5ek-optee-sd"
