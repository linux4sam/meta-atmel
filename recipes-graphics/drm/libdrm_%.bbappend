FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://tests-atmel-support.patch"
