PACKAGECONFIG:append:at91sam9 = " gallium "
PACKAGECONFIG:append:sama5 = " gallium "
