PACKAGECONFIG_remove = " directfb"
PACKAGECONFIG_remove = " vulkan"
PACKAGECONFIG_append = " kms"
