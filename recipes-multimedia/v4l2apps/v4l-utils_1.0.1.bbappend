FILES_libv4l-dev += "${includedir} ${libdir}/libv4l*${SOLIBSDEV} ${libdir}/*.la ${libdir}/pkgconfig"
