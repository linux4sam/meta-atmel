include gstreamer1.0-plugins-hantro.inc

SRCREV = "36dad2f0fc13e9aac2a4a9c850ec63eddbc48e4b"

COMPATIBLE_MACHINE = "sama5d4"
