include gstreamer1.0-plugins-hantro.inc

SRCREV = "4850e2e6b02f67bd55560e64664908af63425cc7"

COMPATIBLE_MACHINE = "sama5d4"
