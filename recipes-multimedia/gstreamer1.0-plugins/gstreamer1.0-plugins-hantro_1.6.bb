include gstreamer1.0-plugins-hantro.inc

SRCREV = "85675fc9701f0f1cf2dbb02cdfcff4ad5389bdad"

COMPATIBLE_MACHINE = "sama5d4"
