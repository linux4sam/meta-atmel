include gstreamer1.0-plugins-hantro.inc

SRCREV = "40d9506e7c4b7df427b3de8fcb17c60f0e72f55a"

COMPATIBLE_MACHINE = "sama5d4"
