include gstreamer1.0-plugins-hantro.inc

SRCREV = "df1d238efc46afcbce074d79294f31d40b2cc777"

COMPATIBLE_MACHINE = "sama5d4"
