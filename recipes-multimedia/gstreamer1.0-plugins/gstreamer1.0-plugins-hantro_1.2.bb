include gstreamer1.0-plugins-hantro.inc

SRCREV = "da3e35583359541711cb186918313c688c7b4ea7"

COMPATIBLE_MACHINE = "sama5d4"
