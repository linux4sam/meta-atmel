include gstreamer1.0-plugins-hantro.inc

SRCREV = "50941639a3b1c287ffc28baa5b786c2c00a9494b"

COMPATIBLE_MACHINE = "sama5d4"
