# if this branch "dev" is not specified the "stable" branch is used
# and this "stable" branch doesn't exists anymore.
QT_MODULE_BRANCH = "dev"
