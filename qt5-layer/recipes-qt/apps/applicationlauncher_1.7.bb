require applicationlauncher.inc

SRC_URI[md5sum] = "27f4a2736d147cf49acce4a9212c4cc6"
SRC_URI[sha256sum] = "1a2c3a232aa4ac464dd1d8cd802a8db928cb0c4e85978df5c10024b80029136d"

#SRC_URI_append_sama5d4 = " file://applicationlauncher_videoplayer.patch"
