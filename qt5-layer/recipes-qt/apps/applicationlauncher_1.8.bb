require applicationlauncher.inc

SRC_URI[md5sum] = "a5f91bc54f063012a380602c2fe10c72"
SRC_URI[sha256sum] = "9d7d64fc3f0770111292e44e12908189b55eb76e7df6fc6277f34ad8ec56fd63"

#SRC_URI_append_sama5d4 = " file://applicationlauncher_videoplayer.patch"
