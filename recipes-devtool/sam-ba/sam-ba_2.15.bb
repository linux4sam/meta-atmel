include sam-ba.inc

SRC_URI[md5sum] = "db236bdb41330958da8e48d0eb812dcc"
SRC_URI[sha256sum] = "a8c2629aee0dc3c684b65771ff55e74b690006e4cfca788e033ea7c2c75a4a83"


