# icu is required to build qtwebkit (unicode support)
PACKAGECONFIG_DEFAULT += "no-xcb icu tslib linuxfb openssl"

