# icu is required to build qtwebkit (unicode support)
PACKAGECONFIG_DEFAULT += "icu"

