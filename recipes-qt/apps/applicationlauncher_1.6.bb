require applicationlauncher.inc

SRC_URI[md5sum] = "f8ebdacf227c56fcb0f11ada3017aa68"
SRC_URI[sha256sum] = "d63c48b8e6d9f3e2fdf501bdf6d077d0f5b2d901741b00118ec8630492ee6ad3"

