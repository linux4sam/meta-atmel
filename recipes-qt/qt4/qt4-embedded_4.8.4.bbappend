FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}-${PV}:"
SRC_URI += "file://qt-embedded-linux-4.8.4-phonon-colors-fix.patch"
