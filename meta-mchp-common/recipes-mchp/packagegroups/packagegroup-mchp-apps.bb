SUMMARY = "Package group for Microchip apps and software."

inherit packagegroup

PROVIDES = "${PACKAGES}"
PACKAGES = " \
    packagegroup-mchp-apps \
"

RDEPENDS:packagegroup-mchp-apps = "\
"
