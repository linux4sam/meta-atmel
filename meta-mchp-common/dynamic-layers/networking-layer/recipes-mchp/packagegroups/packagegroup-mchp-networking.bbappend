
RDEPENDS:packagegroup-mchp-networking += "\
    bridge-utils \
    netcat \
    nftables \
    tcpdump \
    phytool \
"