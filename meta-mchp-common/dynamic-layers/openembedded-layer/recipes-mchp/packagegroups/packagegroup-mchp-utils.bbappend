RDEPENDS:packagegroup-mchp-system-utils += "\
    evtest \
"

RDEPENDS:packagegroup-mchp-hw-utils += "\
    can-utils \
    devmem2 \
    libgpiod-tools \
"

RDEPENDS:packagegroup-mchp-user-utils += "\
    nano \
"

RDEPENDS:packagegroup-mchp-benchmark-utils += "\
    lmbench \
    nbench-byte \
"
