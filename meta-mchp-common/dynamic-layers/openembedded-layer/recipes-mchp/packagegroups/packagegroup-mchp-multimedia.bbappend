PACKAGES += " \
    packagegroup-mchp-multimedia-camera \
"
 
RDEPENDS:packagegroup-mchp-multimedia-camera = "\
    libv4l \
    media-ctl \
    v4l-utils \
    yavta \
    fswebcam \
    libcamera-mchp \
"
