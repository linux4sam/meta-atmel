RDEPENDS:packagegroup-mchp-networking += "\
    hostapd \
    iperf3 \
"
